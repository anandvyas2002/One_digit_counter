ORG 0000H
L1: MOV A,#6FH
MOV P2,A
ACALL DELAY
MOV A,#7FH
MOV P2,A
ACALL DELAY
MOV A,#07H
MOV P2,A
ACALL DELAY
MOV A,#7DH
MOV P2,A
ACALL DELAY
MOV A,#6DH
MOV P2,A
ACALL DELAY
MOV A,#66H
MOV P2,A
ACALL DELAY
MOV A,#4FH
MOV P2,A
ACALL DELAY
MOV A,#5BH
MOV P2,A
ACALL DELAY
MOV A,#06H
MOV P2,A
ACALL DELAY
MOV A,#3FH
MOV P2,A
ACALL DELAY
SJMP L1

DELAY:MOV R2,#12
L5:MOV R3,#100
L4:MOV R4,#25	
L3:MOV R5,#10
L2:DJNZ R5,L2
DJNZ R4,L3
DJNZ R3,L4
DJNZ R2,L5
RET

END